FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

COMPATIBLE = "speedy-box"
